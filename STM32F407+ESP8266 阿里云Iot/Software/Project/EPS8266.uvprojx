# Keil uVision project EPS8266.uvprojx, settings and files
target HY-SGW01(F407) (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: HY-SGW01(F407) +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F429_439xx,USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS;..\Libraries\Stm32f40x_StdPeriph_Driver\inc;..\Main;..\Source\Inc;..\HMAC\inc;..\SYSTEM\delay;..\SYSTEM\sys
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Main
    ../Main/: main.c
  group Source
    ../Source/Src/: Usart1deal.c Usart2deal.c Timer4.c Keydeal.c Leddeal.c Mqtt.c Timer1.c Timer3.c Wifi.c Datamath.c Mystring.c
    ../HMAC/scr/: utils_hmac.c utils_md5.c utils_sha1.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/delay/: delay.c
  group Libraries
    ../Libraries/Stm32f40x_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c stm32f4xx_fmc.c
  group CMSIS
    ../Libraries/CMSIS/: startup_stm32f429xx.s
  group System
    ../Main/: stm32f4xx_it.c system_stm32f4xx.c
